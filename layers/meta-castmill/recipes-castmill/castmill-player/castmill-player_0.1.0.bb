SUMMARY = "Castmill OS kiosk shell for the Castmill player"
DESCRIPTION = "Electron app (one process per output) that shows the pairing \
screen, then the Castmill player, and reports frames, capabilities and \
playback stats to castmill-agent. Source: player/ in this repository."
# TODO: project license (open question in spec 01).
LICENSE = "CLOSED"

FILESEXTRAPATHS:prepend := "${CASTMILL_REPO_DIR}:${THISDIR}/files:"
SRC_URI = " \
    file://player;subdir=${BP} \
    file://castmill-player \
"
S = "${UNPACKDIR}/${BP}/player"

INHIBIT_DEFAULT_DEPS = "1"
do_configure[noexec] = "1"
do_compile[noexec] = "1"

# Chromium flags per platform (spec 06). Hardware decoding flags must be
# re-verified on every Electron upgrade (spec 06 "Verification method").
CASTMILL_ELECTRON_FLAGS = " \
    --ozone-platform=wayland \
    --enable-gpu-rasterization \
    --disable-renderer-backgrounding \
    --disable-background-timer-throttling \
    --noerrdialogs \
    --no-first-run \
"
# Intel/AMD: VA-API (not officially supported by Chromium on Linux).
CASTMILL_ELECTRON_FLAGS:append:genericx86-64 = " \
    --enable-features=AcceleratedVideoDecodeLinuxGL,AcceleratedVideoDecodeLinuxZeroCopyGL,VaapiIgnoreDriverChecks \
    --ignore-gpu-blocklist \
"
# Raspberry Pi 5: decoder path to be confirmed in the Phase 0 benchmark.
CASTMILL_ELECTRON_FLAGS:append:raspberrypi5 = " --ignore-gpu-blocklist"
# Development VM: virtio-gpu without 3D; Chromium falls back to SwiftShader.
CASTMILL_ELECTRON_FLAGS:append:genericarm64 = " --enable-unsafe-swiftshader"
PACKAGE_ARCH = "${MACHINE_ARCH}"

do_install() {
    install -d ${D}${nonarch_libdir}/castmill-player/app
    install -m 0644 ${S}/package.json ${D}${nonarch_libdir}/castmill-player/
    for f in main.js preload.js agentlink.js policy.js status.html status.css status.js; do
        install -m 0644 ${S}/app/$f ${D}${nonarch_libdir}/castmill-player/app/
    done
    install -D -m 0755 ${UNPACKDIR}/castmill-player ${D}${bindir}/castmill-player

    install -d ${D}${sysconfdir}/castmill
    echo "# Generated by meta-castmill for ${MACHINE}. One flag per line." > ${D}${sysconfdir}/castmill/electron-flags.conf
    for f in ${CASTMILL_ELECTRON_FLAGS}; do
        echo "$f" >> ${D}${sysconfdir}/castmill/electron-flags.conf
    done
}
do_install[vardeps] += "CASTMILL_ELECTRON_FLAGS"

FILES:${PN} += "${nonarch_libdir}/castmill-player"
RDEPENDS:${PN} = "electron-bin"
