FILESEXTRAPATHS:prepend := "${LAYERDIR_castmill}/recipes-kernel/linux/files:"
SRC_URI:append = " file://castmill.cfg"
